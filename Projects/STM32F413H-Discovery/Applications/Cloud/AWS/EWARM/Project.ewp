# IAR project Project.ewp, settings and files
configuration STM32F413H_DISCOVERY (ARM, debug)
  General.OGChipSelectEditMenu: STM32F413ZH ST STM32F413ZH
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F413xx; USE_HAL_DRIVER; USE_STM32F413H_DISCOVERY; MBEDTLS_CONFIG_FILE=<aws_mbedtls_config.h>; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; ENABLE_IOT_WARNING; USE_MBED_TLS; AWS; STM32F413xx; USE_WIFI
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F413H-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Utilities\Log; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Common\AWS\Inc; ..\..\..\..\..\Common\Shared\Inc; ..\..\..\..\..\..\Middlewares\Third_Party\AWS\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include; ..\..\..\..\..\..\Drivers\BSP\Components\es_wifi
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F413ZH_DISCOVERY_Cloud_XXX_Vx.y.z.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f413xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c flash_f4.c
  group Application/AWS
    ../../../../../Common/AWS/Src/: aws_network_st_wrapper.c aws_subscribe_publish_sensor_values.c aws_timer.c
  group Application/Common
    ../../../../../Common/Shared/Src/: cloud.c entropy_hardware_poll.c heap.c http_util.c iot_flash_config.c mbedtls_net.c mbedtls_patch.c net.c net_tls_mbedtls.c rfu.c STM32CubeRTCInterface.c timingSystem.c timedate.c wifi_net.c net_tcp_wifi.c
  group Application/EWARM
    ./: startup_stm32f413xx.s
  group Application/Wifi
    ../Src/: es_wifi_io.c wifi.c
  group Drivers/BSP
    ../../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/BSP/STM32F413H-Discovery
    ../../../../../../Drivers/BSP/STM32F413H-Discovery/: stm32f413h_discovery.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_ll_fsmc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/Third_Party/AWS
    ../../../../../../Middlewares/Third_Party/AWS/src/: aws_iot_mqtt_client.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client_connect.c aws_iot_mqtt_client_publish.c aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_yield.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
